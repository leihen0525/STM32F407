# IAR project STM32F407.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; F:\Project.Software\Master.System\Master.OS\Includes; F:\Project.Software\Master.System\Master.COM\Master.COM.Ethernet\Includes; F:\Project.Software\Master.System\Master.Drivers\Master.Drivers.STM32F407\Includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F407.hex
  ILINK.IlinkOutputFile: STM32F407.out
  ILINK.IlinkIcfFile: F:\Project.Software\Master.System\Master.OS\Config\STM32F407xG.icf
  ILINK.IlinkExtraOptions: --whole_archive F:\Project.Software\Master.System\Master.BSP\Master.BSP.STM32F407\Release.Library\Master.BSP.STM32F407.a; --whole_archive F:\Project.Software\Master.System\Master.OS\Release.Library\Master.OS.ARM.V7.M4.a; --whole_archive F:\Project.Software\Master.System\Master.COM\Master.COM.Ethernet\Release.Library\Master.COM.Ethernet.ARM.M4.a; --whole_archive F:\Project.Software\Master.System\Master.Drivers\Master.Drivers.STM32F407\Release.Library\Master.Drivers.STM32F407.a; --whole_archive F:\Project.Software\Master.System\Master.Library\Master.Library.Peripherals.STM32\Release.Library\Master.Library.Peripherals.STM32F407.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Ethernet
    Ethernet/: Ethernet.c Ethernet.h Ethernet.Struct.h
  group Ethernet/Ethernet.PHY.LAN8742A
    Ethernet/Ethernet.PHY.LAN8742A/: Ethernet.PHY.LAN8742A.c Ethernet.PHY.LAN8742A.Define.h Ethernet.PHY.LAN8742A.Enum.h Ethernet.PHY.LAN8742A.h
